# Keil uVision project template.uvprojx, settings and files
target template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f403a_407_board;..\mdk_v5;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\Library\CST816T;.\Library\I2C;.\Library\LCD;.\Library\SPI;.\GUI;.\GUI\lvgl_driver;.\GUI_Demo;.\GUI\lvgl\src;.\GUI\lvgl\src\extra\widgets\menu;.\GUI\lv_demos\lv_demo_stress;.\GUI\lv_demos\lv_demo_stress\assets;.\Library\Timer;.\GUI\lv_demos\lv_demo_benchmark;.\GUI\lv_demos\lv_demo_benchmark\assets;.\Library\KEY_NVIC;.\Library\RTC;.\Library\WS2812B;.\Library\W25Q128;.\Library\Fontupd;.\Library\ADC;..\inc;..\device_support\startup\mdk;..\at32f403a_407_board;..\drivers\inc;..\core_support;.\Library\WWDG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
  group bsp
    ../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../device_support/: system_at32f403a_407.c
    ../device_support/startup/mdk/: startup_at32f403a_407.s
  group readme
    ../: readme.txt
  group Free_RTOS_Creo
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Free_RTOS_Palat
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Library
    ./Library/CST816T/: CST816.c
    ./Library/I2C/: I2C.c
    ./Library/LCD/: lcd.c lcd_init.c
    ./Library/SPI/: spi.c
    ./Library/Timer/: Timer.c
    ./Library/KEY_NVIC/: KEY_NVIC.c
    ./Library/RTC/: rtc.c
    ./Library/WS2812B/: ws2812b.c
    ./Library/W25Q128/: W25Q128.c
    ./Library/Fontupd/: fontupd.c text.c
    ./Library/ADC/: ADC.c
  group GUI
    ./GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./GUI/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ./GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ./GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ./GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ./GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ./GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ./GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ./GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ./GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ./GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ./GUI/lvgl/src/extra/: lv_extra.c
    ./GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_dropdown.c lv_checkbox.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ./GUI/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group GUI_Demo
    ./GUI_Demo/: LVGL_Main.c LVGL_PORT_1.c LVGL_PORT_2.c LVGL_PORT_3.c LVGL_PORT_4.c HZ.c LVGL_PORT.c LVGL_PORT_5.c LVGL_PORT_6.c
  group Picture
    ./Picture/: Games.c LV_Eglish.c RTC.c Set.c Song.c Timer.c obs_1.c obs_2.c 24Dom.c cloud.c ba_1.c bg_2.c time_bg.c own_Word.c
  group WWDG
    ./Library/WWDG/: WWDG.c
